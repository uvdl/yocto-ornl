# remove X11
# https://github.com/e8johan/meta-diet

PACKAGECONFIG_remove = "x11"