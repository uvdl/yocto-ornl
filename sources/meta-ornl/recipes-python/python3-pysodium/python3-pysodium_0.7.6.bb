DESCRIPTION = "This is a very simple wrapper around libsodium masquerading as nacl."
SECTION = "devel/python"

LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=63455d5536b401db53d4973c9d6399ea"

SRC_URI[md5sum] = "49f8844b50df57be44db2d79bbee3ca3"
SRC_URI[sha256sum] = "c134fe54ba034f3b2a1a85f8ac2eba4b1c36263e68f93aaf9bb1c21f017c28bd"

inherit pypi setuptools3