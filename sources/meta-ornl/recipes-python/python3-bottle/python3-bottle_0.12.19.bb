DESCRIPTION = "Bottle is a fast and simple micro-framework for small web applications. "
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ab52dc5a6e00b0f2f281e5fff61326aa"

SRC_URI[md5sum] = "50075544706b5e662a3fbd9a98e24b07"
SRC_URI[sha256sum] = "a9d73ffcbc6a1345ca2d7949638db46349f5b2b77dac65d6494d45c23628da2c"

inherit pypi setuptools3