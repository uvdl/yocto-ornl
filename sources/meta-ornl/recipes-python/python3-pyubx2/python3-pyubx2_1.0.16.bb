DESCRIPTION = "pyubx2 is an original Python library for the UBX © protocol. UBX is a proprietary binary protocol implemented on u-blox ™ GNSS/GPS receiver modules."
SECTION = "devel/python"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1060595a01b98f7b33b9f8d5b111c0dd"

SRC_URI[md5sum] = "191ebc67f725d1f2a8d298b9f0c02368"
SRC_URI[sha256sum] = "b12f275d31e042e0467bf0bea761f179468ce6bc5ac95975f5c743f55bb79db0"

inherit pypi setuptools3