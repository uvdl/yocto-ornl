DESCRIPTION = "pynmea2 is a python library for the NMEA 0183 protocol"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=bb5e173bc54080cb25079199959ba6b6"

SRC_URI[md5sum] = "b753a629c87a072604352c1aecee463d"
SRC_URI[sha256sum] = "8b83fa7e3e668af5e182ef1c2fd4a535433ecadf60d7b627280172d695a1646b"

inherit pypi setuptools3