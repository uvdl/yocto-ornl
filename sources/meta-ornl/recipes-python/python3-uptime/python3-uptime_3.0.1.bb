DESCRIPTION = "This module provides a cross-platform way to retrieve system uptime and boot time."
SECTION = "devel/python"

LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://COPYING.txt;md5=63455d5536b401db53d4973c9d6399ea"

SRC_URI[md5sum] = "046063e97abbee37bf8de3fd16df674d"
SRC_URI[sha256sum] = "7c300254775b807ce46e3dcbcda30aa3b9a204b9c57a7ac1e79ee6dbe3942973"

inherit pypi setuptools3