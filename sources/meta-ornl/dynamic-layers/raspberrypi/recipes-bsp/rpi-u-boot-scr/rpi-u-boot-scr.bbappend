FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE = "raspberrypi4-64"