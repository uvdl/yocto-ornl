COMPATIBLE_MACHINE = "^rpi$"

SRC_URI = " file://config.patch"