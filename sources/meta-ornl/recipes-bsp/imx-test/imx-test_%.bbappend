COMPATIBLE_MACHINE = "pix-c3"