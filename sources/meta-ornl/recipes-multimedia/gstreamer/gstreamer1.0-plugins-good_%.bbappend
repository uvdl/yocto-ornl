PACKAGECONFIG += " \ 
    multifile \
"
