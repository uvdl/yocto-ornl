PACKAGECONFIG_raspberrypi4-64 += " \
    alsa \ 
    jpeg \
"