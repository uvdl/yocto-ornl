PACKAGECONFIG += " rtmp"