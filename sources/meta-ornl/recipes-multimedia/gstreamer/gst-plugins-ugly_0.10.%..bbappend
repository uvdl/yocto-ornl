COMPATIBLE_MACHINE = "var-som-mx6-ornl"
PACKAGECONFIG += " \ 
    x264 \
"