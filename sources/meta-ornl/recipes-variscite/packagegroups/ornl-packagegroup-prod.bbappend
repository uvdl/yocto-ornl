
RDEPENDS_${PN} += " \
    packagegroup-fsl-tools-gpu \
	packagegroup-fsl-tools-gpu-external \
    imx-test \
"